# Keil uVision project F1_RTT_LITTLEVGL.uvprojx, settings and files
target F1_RTT_LITTLEVGL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F205VG GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x020000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F1_RTT_LITTLEVGL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL,LV_CONF_INCLUDE_SIMPLE
  c include: ..\gdStdLib200\GD32F20x_standard_peripheral\Include;..\gdStdLib200\CMSIS\GD\GD32F20x\Include;..\gdStdLib200\CMSIS;..\neceFie;..\usrLib\inc;..\RTT_deviceLib\inc;..\RTT_kernel\inc;..\RTT_usrTask\inc;..\config_File;..\lvgl;..\lvgl\lv_core;..\lvgl\lv_draw;..\lvgl\lv_fonts;..\lvgl\lv_hal;..\lvgl\lv_misc;..\lvgl\lv_objx;..\lvgl\lv_themes;..\lvgl_usrGui\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group gdStdLib200
    ../gdStdLib200/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
    ../gdStdLib200/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group configFile
    ../config_File/: gd32f20x_libopt.h main.h rtconfig.h lv_conf.h
    ../gdStdLib200/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group neceFile
    ../neceFile/: gd32f20x_it.c main.c systick.c
  group usrLib
    ../usrLib/src/: adcTvoc.c ControlData.c driveLcd.c hwManage.c lcdBright.c SensorData.c sensorPowerCtrl.c T_H_drive.c touchExti.c touchI2c.c uart0Hcho.c uart1Pm25.c uart2_485.c uart3Co2.c uart6_433.c uart7_wifi.c userRTC.c usrBuzz.c usrFlash.c usrJdq.c usrTimer.c usrUtility.c
  group RTT/DeviceLib
    ../RTT_deviceLib/src/: workqueue.c
    ../RTT_deviceLib/inc/: rtdevice.h
  group RTT/kernel
    ../RTT_kernel/src/: clock.c components.c context_rvds.S cpuport.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group RTT/usrTask
    ../RTT_usrTask/src/: usrTask.c co2_Task.c hchoTask.c pm25Task.c usrIdleTask.c usrGuiTask.c
  group lvgl/core
    ../lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lvgl/draw
    ../lvgl/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rbasic.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vbasic.c
  group lvgl/fonts
    ../lvgl/lv_fonts/: lv_font_builtin.c lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group lvgl/port
    ../lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/misc
    ../lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_ufs.c
  group lvgl/objx
    ../lvgl/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group lvgl/themes
    ../lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lvgl/usrGui
    ../lvgl_usrGui/src/: adjustTime.c mainDisp.c powerOffDisp.c setDisp.c usrGuiPort.c
  group lvgl/usrGuiLib
    ../lvgl_usrGuiLib/: msyh20.c pm25Num.c
